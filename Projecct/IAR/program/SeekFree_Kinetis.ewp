# IAR project SeekFree_Kinetis.ewp, settings and files
configuration MK66FX_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\FatFs; ..\..\..\Libraries\FatFs\option; ..\..\..\Libraries\XMU\Bottom; ..\..\..\Libraries\XMU\Control; ..\..\..\Libraries\XMU\ICM; ..\..\..\Libraries\XMU\Image; ..\..\..\Libraries\XMU\Main; ..\..\..\Libraries\XMU\Balance
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_Kinetis.srec
  ILINK.IlinkOutputFile: SeekFree_Kinetis.out
  ILINK.IlinkIcfFile: linker\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/inc
    ../../../Libraries/drives/inc/: common.h misc.h MK60_adc.h MK60_cmt.h MK60_dac.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_savedata.h MK60_sdhc.h MK60_spi.h MK60_systick.h MK60_uart.h MK60_wdog.h
  group drives/src
    ../../../Libraries/drives/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_savedata.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group fatfs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group seekfree
    ../../../Libraries/seekfree/: font.c font.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK66F18.s
    ../../../Libraries/startup/DeviceSupport/: system_MK66.c
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/: version.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h
  group XMU/Balance
    ../../../Libraries/XMU/Balance/: Angle.c Angle.h Basic.c Basic.h Direction.c Direction.h Speed.c Speed.h
  group XMU/Bottom
    ../../../Libraries/XMU/Bottom/: AD.c AD.h Bluetooth.c Bluetooth.h BMP.c BMP.h crc.cpp crc.h DFLASH.c DFLASH.h Init.c Init.h keyboard.c keyboard.h Menu.c Menu.h OLED.c OLED.h Screen.c Screen.h TFCard.c TFCard.h
  group XMU/Control
    ../../../Libraries/XMU/Control/: Circleland.c Circleland.h DelayDist.c DelayDist.h Meeting.c Meeting.h Message.c Message.h RampandBlock.c RampandBlock.h TurnTail.c TurnTail.h
    ../../../Libraries/XMU/Image/: Obstacle.c Obstacle.h
  group XMU/ICM
    ../../../Libraries/XMU/ICM/: filter.c filter.h icm20602.c icm20602.h mpu_prepare.c mpu_prepare.h mymath.c mymath.h MySPI.c MySPI.h PID.c PID.h XMU_IMU.c XMU_IMU.h
  group XMU/Image
    ../../../Libraries/XMU/Image/: BasicFun.cpp BasicFun.h canny.cpp canny.h CircleIsland.cpp CircleIsland.h FillSpecialLine.cpp FillSpecialLine.h FindLine.cpp FindLine.h MainProcess.cpp MainProcess.h queue.h SpecialElem.cpp SpecialElem.h
  group XMU/Main
    ../../../Libraries/XMU/Main/: CameraDisplay.c CameraDisplay.h
    ../../../Libraries/XMU/Image/: GlobalVar.cpp GlobalVar.h
